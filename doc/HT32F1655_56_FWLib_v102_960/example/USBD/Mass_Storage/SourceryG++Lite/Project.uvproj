# Keil uVision project Project.uvproj, settings and files
target HT32 (ARM-GNU)
  device: HT32F1656 Holtek
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x00000000-0x0003FBFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HT32 +hex
  group User
    ../: main.c ht32f165x_it.c ht32_usbd_class.c ht32_usbd_descriptor.c usb_bulk_only_transport.c usb_scsi_block_command.c ram_disk.c sd_disk.c spi_sd.c
  group Config
    ../: ht32f1655_56_conf.h ht32f165x_usbdconf.h
    ./: HT32F165x_DebugSupport.ini
  group CMSIS
    ../: system_ht32f165x.c
  group Sourcery G++Lite
    ./: startup_ht32f165x.s
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Library
    ../../../../library/HT32F1655_56_Driver/src/: ht32_cm3_misc.c ht32f1655_56_adc.c ht32f1655_56_bftm.c ht32f1655_56_ckcu.c ht32f1655_56_cmp_op.c ht32f1655_56_crc.c ht32f1655_56_ebi.c ht32f1655_56_exti.c ht32f1655_56_flash.c ht32f1655_56_gpio.c ht32f1655_56_gptm.c ht32f1655_56_i2c.c ht32f1655_56_i2s.c ht32f1655_56_mctm.c ht32f1655_56_pdma.c ht32f1655_56_pwrcu.c ht32f1655_56_rstcu.c ht32f1655_56_rtc.c ht32f1655_56_sci.c ht32f1655_56_spi.c ht32f1655_56_usart.c ht32f1655_56_usbd.c ht32f1655_56_wdt.c
  group Retarget
    ../../../../library/HT32F1655_56_Driver/src/: ht32_retarget.c ht32_serial.c printf.c syscalls.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: i2c_eeprom.c spi_flash.c ebi_lcd.c
  group Doc
    ../: readme.txt
