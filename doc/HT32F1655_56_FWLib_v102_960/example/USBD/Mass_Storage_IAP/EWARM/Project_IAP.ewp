# IAR project Project_IAP.ewp, settings and files
configuration IAP (ARM, debug)
  General.OGChipSelectEditMenu: HT32F1656 Holtek HT32F1656
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HT32_DRIVER; USE_HT32F1656_DVB
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\library\HT32F1655_56_Driver\inc; ..\..\..\..\library\CMSIS\Include; ..\..\..\..\library\Device\Holtek\HT32F1655_56\Include; ..\..\..\..\library\HT32_USBD_Library\inc; ..\..\..\..\utilities; ..\Src_IAP
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAP_AP.hex
  ILINK.IlinkOutputFile: IAP_AP.out
  ILINK.IlinkKeepSymbols: ap
  ILINK.IlinkIcfFile: linker_iap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../Src_IAP/: iap_system_ht32f165x.c
  group Config
    ./: ht32_op.c
    ../Src_IAP/: ht32f1655_56_conf.h ht32f165x_usbdconf.h
  group Doc
    ../: readme.txt
  group EWARM
    ./: startup_ht32f165x_iap.s
  group Library
    ../../../../library/HT32F1655_56_Driver/src/: ht32_cm3_misc.c ht32f1655_56_adc.c ht32f1655_56_bftm.c ht32f1655_56_ckcu.c ht32f1655_56_cmp_op.c ht32f1655_56_crc.c ht32f1655_56_ebi.c ht32f1655_56_exti.c ht32f1655_56_flash.c ht32f1655_56_gpio.c ht32f1655_56_gptm.c ht32f1655_56_i2c.c ht32f1655_56_i2s.c ht32f1655_56_mctm.c ht32f1655_56_pdma.c ht32f1655_56_pwrcu.c ht32f1655_56_rstcu.c ht32f1655_56_rtc.c ht32f1655_56_sci.c ht32f1655_56_spi.c ht32f1655_56_usart.c ht32f1655_56_usbd.c ht32f1655_56_wdt.c
  group Retarget
    ../../../../library/HT32F1655_56_Driver/src/: ht32_retarget.c ht32_serial.c
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group User
    ./: iap_flash_disk.a iap_handler.a
    ../Src_IAP/: iap_ht32_usbd_class.c iap_ht32_usbd_descriptor.c iap_ht32f165x_it.c iap_main.c iap_usb_bulk_only_transport.c iap_usb_scsi_block_command.c
  group Utilities
    ../../../../utilities/common/: ebi_lcd.c i2c_eeprom.c spi_flash.c
    ../../../../utilities/: ht32_board.c
