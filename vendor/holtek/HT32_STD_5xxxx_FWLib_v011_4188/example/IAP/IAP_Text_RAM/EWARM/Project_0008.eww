<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project_0008_AP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Project_0008_IAP.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Project</name>
      <member>
        <project>Project_0008_AP</project>
        <configuration>HT32</configuration>
      </member>
      <member>
        <project>Project_0008_IAP</project>
        <configuration>HT32</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


