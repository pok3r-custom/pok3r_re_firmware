<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project_57352_AP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Project_57352_IAP.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Project</name>
      <member>
        <project>Project_57352_AP</project>
        <configuration>HT32</configuration>
      </member>
      <member>
        <project>Project_57352_IAP</project>
        <configuration>HT32</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


