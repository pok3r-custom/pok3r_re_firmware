# IAR project Project_52367_IAP.ewp, settings and files
configuration HT32 (ARM, debug)
  General.OGChipSelectEditMenu: HT32F52367 Holtek HT32F52367
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HT32_DRIVER; USE_HT32F52367_SK; USE_HT32F52357_67; USE_MEM_HT32F52367
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\library\HT32F5xxxx_Driver\inc; ..\..\..\..\library\CMSIS\Include; ..\..\..\..\library\Device\Holtek\HT32F5xxxx\Include; ..\..\..\..\library\HT32_USBD_Library\inc; ..\..\..\..\utilities; ..\Src_IAP
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: USE_HT32_CHIP=11
  OBJCOPY.OOCOutputFile: IAP_AP.hex
  ILINK.IlinkOutputFile: IAP_AP.out
  ILINK.IlinkKeepSymbols: ap
  ILINK.IlinkIcfFile: linker_iap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../Src_IAP/: iap_system_ht32f5xxxx_03.c
  group Config
    ./: ht32_op.c
    ../Src_IAP/: ht32f5xxxx_conf.h ht32f5xxxx_01_usbdconf.h
  group Doc
    ../: readme.txt
  group EWARM
    ./: startup_ht32f5xxxx_iar_03_iap.s
  group Library
    ../../../../library/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_aes.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_dac.c ht32f5xxxx_div.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
  group Retarget
    ../../../../library/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group User
    ./: iap_flash_disk.a iap_handler.a
    ../Src_IAP/: iap_ht32_usbd_class.c iap_ht32_usbd_descriptor.c iap_ht32f5xxxx_01_it.c iap_main.c iap_usb_bulk_only_transport.c iap_usb_scsi_block_command.c
  group Utilities
    ../../../../utilities/common/: ebi_lcd.c i2c_eeprom.c spi_flash.c
    ../../../../utilities/: ht32_board.c
