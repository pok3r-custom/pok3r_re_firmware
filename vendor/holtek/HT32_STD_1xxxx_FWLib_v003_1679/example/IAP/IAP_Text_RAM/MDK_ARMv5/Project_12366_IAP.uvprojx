# Keil uVision project Project_12366_IAP.uvprojx, settings and files
target IAP (ARM-ADS)
  device: HT32F12366 Holtek
  pack: Holtek.HT32_DFP.1.0.9
  cpu: IROM(0x00000000-0x0003FBFF) IRAM(0x20000000-0x2001FFFF) CPUTYPE("Cortex-M3") CLOCK(8000000)
  output: IAP +hex
  AfterMake: fromelf --bin -o "!L.bin" "!L"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F12366_SK, USE_HT32F12365_66, USE_MEM_HT32F12366
  c include: ..\Src_IAP;..\;..\..\..\..\library\HT32F1xxxx_Driver\inc;..\..\..\..\library\CMSIS\Include;..\..\..\..\library\Device\Holtek\HT32F1xxxx\Include;..\..\..\..\library\HT32_USBD_Library\inc;..\..\..\..\utilities
  asm define: USE_HT32_CHIP=2
  library: MicroLIB
  scatter file: .\linker_iap.lin
  link misc: --entry Reset_Handler
  group User
    ../Src_IAP/: iap_main.c iap_ht32f1xxxx_01_it.c iap_handler.c iap_xmodem.c iap_buffer.c iap_crc16.c
  group Config
    ../Src_IAP/: ht32f1xxxx_conf.h ht32f1xxxx_01_usbdconf.h
    ./: ht32_op.s HT32F1xxxx_01_DebugSupport.ini
  group CMSIS
    ../Src_IAP/: system_ht32f1xxxx_02.c
  group MDK-ARM
    ./: startup_ht32f1xxxx_01_iap.s
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Library
    ../../../../library/HT32F1xxxx_Driver/src/: ht32_cm3_misc.c ht32f1xxxx_adc.c ht32f1xxxx_aes.c ht32f1xxxx_bftm.c ht32f1xxxx_ckcu.c ht32f1xxxx_cmp.c ht32f1xxxx_crc.c ht32f1xxxx_ebi.c ht32f1xxxx_exti.c ht32f1xxxx_flash.c ht32f1xxxx_gpio.c ht32f1xxxx_i2c.c ht32f1xxxx_i2s.c ht32f1xxxx_mctm.c ht32f1xxxx_pdma.c ht32f1xxxx_pwrcu.c ht32f1xxxx_rstcu.c ht32f1xxxx_rtc.c ht32f1xxxx_sci.c ht32f1xxxx_sdio.c ht32f1xxxx_spi.c ht32f1xxxx_tm.c ht32f1xxxx_usart.c ht32f1xxxx_usbd.c ht32f1xxxx_wdt.c ht32f2xxxx_csif.c
  group Retarget
    ../../../../library/HT32F1xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: i2c_eeprom.c spi_flash.c ebi_lcd.c
  group Doc
    ../: readme.txt
