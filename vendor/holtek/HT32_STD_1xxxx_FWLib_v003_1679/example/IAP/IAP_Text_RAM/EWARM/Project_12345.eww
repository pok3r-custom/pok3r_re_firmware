<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project_12345_AP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Project_12345_IAP.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Project</name>
      <member>
        <project>Project_12345_AP</project>
        <configuration>HT32</configuration>
      </member>
      <member>
        <project>Project_12345_IAP</project>
        <configuration>HT32</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


