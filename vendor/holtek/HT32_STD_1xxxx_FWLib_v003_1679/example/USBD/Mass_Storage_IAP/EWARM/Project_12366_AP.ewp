# IAR project Project_12366_AP.ewp, settings and files
configuration AP (ARM, debug)
  General.OGChipSelectEditMenu: HT32F12366 Holtek HT32F12366
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HT32_DRIVER; USE_HT32F12366_SK; USE_HT32F12365_66; USE_MEM_HT32F12366
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\library\HT32F1xxxx_Driver\inc; ..\..\..\..\library\CMSIS\Include; ..\..\..\..\library\Device\Holtek\HT32F1xxxx\Include; ..\..\..\..\library\HT32_USBD_Library\inc; ..\..\..\..\utilities; ..\Src_AP
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: USE_HT32_CHIP=2
  OBJCOPY.OOCOutputFile: AP.bin
  ILINK.IlinkOutputFile: Project_12366_AP.out
  ILINK.IlinkIcfFile: linker_12366.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../Src_AP/: system_ht32f1xxxx_02.c
  group Config
    ./: ht32_op.c
    ../Src_AP/: ht32f1xxxx_conf.h ht32f1xxxx_01_usbdconf.h
  group Doc
    ../: readme.txt
  group EWARM
    ./: startup_ht32f1xxxx_01.s
  group Library
    ../../../../library/HT32F1xxxx_Driver/src/: ht32_cm3_misc.c ht32f1xxxx_adc.c ht32f1xxxx_aes.c ht32f1xxxx_bftm.c ht32f1xxxx_ckcu.c ht32f1xxxx_cmp.c ht32f1xxxx_crc.c ht32f1xxxx_ebi.c ht32f1xxxx_exti.c ht32f1xxxx_flash.c ht32f1xxxx_gpio.c ht32f1xxxx_i2c.c ht32f1xxxx_i2s.c ht32f1xxxx_mctm.c ht32f1xxxx_pdma.c ht32f1xxxx_pwrcu.c ht32f1xxxx_rstcu.c ht32f1xxxx_rtc.c ht32f1xxxx_sci.c ht32f1xxxx_sdio.c ht32f1xxxx_spi.c ht32f1xxxx_tm.c ht32f1xxxx_usart.c ht32f1xxxx_usbd.c ht32f1xxxx_wdt.c ht32f2xxxx_csif.c
  group Retarget
    ../../../../library/HT32F1xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group User
    ../Src_AP/: ht32f1xxxx_01_it.c main.c
  group Utilities
    ../../../../utilities/common/: ebi_lcd.c i2c_eeprom.c spi_flash.c
    ../../../../utilities/: ht32_board.c
