# IAR project Project_1656_IAP.ewp, settings and files
configuration IAP (ARM, debug)
  General.OGChipSelectEditMenu: HT32F1656 Holtek HT32F1656
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HT32_DRIVER; USE_HT32F1656_DVB; USE_HT32F1655_56; USE_MEM_HT32F1656
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\library\HT32F1xxxx_Driver\inc; ..\..\..\..\library\CMSIS\Include; ..\..\..\..\library\Device\Holtek\HT32F1xxxx\Include; ..\..\..\..\library\HT32_USBD_Library\inc; ..\..\..\..\utilities; ..\Src_IAP
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: USE_HT32_CHIP=1
  OBJCOPY.OOCOutputFile: IAP_AP.hex
  ILINK.IlinkOutputFile: Project_1656_IAP.out
  ILINK.IlinkKeepSymbols: ap
  ILINK.IlinkIcfFile: linker_1656._iap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../Src_IAP/: system_ht32f1xxxx_01.c
  group Config
    ./: ht32_op.c
    ../Src_IAP/: ht32f1xxxx_01_usbdconf.h ht32f1xxxx_01_usbdconf.h
  group Doc
    ../: readme.txt
  group EWARM
    ./: startup_ht32f1xxxx_01_iap.s
  group Library
    ../../../../library/HT32F1xxxx_Driver/src/: ht32_cm3_misc.c ht32f1xxxx_adc.c ht32f1xxxx_bftm.c ht32f1xxxx_ckcu.c ht32f1xxxx_cmp_op.c ht32f1xxxx_crc.c ht32f1xxxx_ebi.c ht32f1xxxx_exti.c ht32f1xxxx_flash.c ht32f1xxxx_gpio.c ht32f1xxxx_i2c.c ht32f1xxxx_i2s.c ht32f1xxxx_mctm.c ht32f1xxxx_pdma.c ht32f1xxxx_pwrcu.c ht32f1xxxx_rstcu.c ht32f1xxxx_rtc.c ht32f1xxxx_sci.c ht32f1xxxx_spi.c ht32f1xxxx_tm.c ht32f1xxxx_usart.c ht32f1xxxx_usbd.c ht32f1xxxx_wdt.c
  group Retarget
    ../../../../library/HT32F1xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group User
    ./: iap_flash_disk_1656.a iap_handler_1656.a
    ../Src_IAP/: iap_ht32_usbd_class.c iap_ht32_usbd_descriptor.c iap_ht32f1xxxx_01_it.c iap_main.c iap_usb_bulk_only_transport.c iap_usb_scsi_block_command.c
  group Utilities
    ../../../../utilities/common/: ebi_lcd.c i2c_eeprom.c spi_flash.c
    ../../../../utilities/: ht32_board.c
